<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\boot_loader_uart_nucleo_F767ZI.ewp</path>
  </project>
  <batchBuild />
</workspace>
